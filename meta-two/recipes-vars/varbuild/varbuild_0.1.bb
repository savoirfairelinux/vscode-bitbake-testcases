DESCRIPTION = "\
  Demonstrate variable usage \
  for setting up a class task \
"
PR = "r1"

# Should suggest "BUILDARGS" on typing
BUILDARGS = "my build arguments"

# Should suggest "varbuild" on typing
inherit varbuild
